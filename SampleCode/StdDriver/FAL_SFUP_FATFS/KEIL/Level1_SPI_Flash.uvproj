# Keil uVision project Level1_SPI_Flash.uvproj, settings and files
target Level1_SPI_Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: Level1_SPI_Flash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\fal-master\inc;..\fal-master\samples\porting;..\sfud\inc;..\ff8\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c uart.c spi.c gpio.c fmc.c
  group User
    ../: main.c FAL_WARP.C
  group fal
    ../fal-master/src/: fal.c fal_flash.c fal_partition.c
    ../fal-master/samples/porting/: fal_flash_m031_port.c fal_flash_sfud_port.c
  group sfud
    ../sfud/src/: sfud.c sfud_sfdp.c
    ../sfud/port/: sfud_port.c
  group FATFS
    ../ff8/src/: diskio.c ff.c
    ../ff8/src/option/: ccsbcs.c
