# Keil uVision project SPI_Flash.uvprojx, settings and files
target SPI_Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: SPI_Flash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\ff8\src;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../Library/StdDriver/src/: uart.c clk.c retarget.c spi.c sys.c gpio.c
  group User
    ../: main.c SPI_FLASH.C
    ../ff8/src/: diskio.c ff.c
    ../ff8/src/option/: ccsbcs.c
